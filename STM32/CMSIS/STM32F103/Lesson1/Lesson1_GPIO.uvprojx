# Keil uVision project Lesson1_GPIO.uvprojx, settings and files
target Lesson1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Lesson1_GPIO +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Lesson1;.\CMSIS\inc;.\Code\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ./Startup/: startup_stm32f10x_md_vl.s
  group CMSIS
    ./CMSIS/src/: core_cm3.c system_stm32f10x.c
  group Code
    ./Code/src/: main.c
