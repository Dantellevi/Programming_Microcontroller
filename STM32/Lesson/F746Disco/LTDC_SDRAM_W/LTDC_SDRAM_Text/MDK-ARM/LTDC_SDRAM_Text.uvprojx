# Keil uVision project LTDC_SDRAM_Text.uvprojx, settings and files
target LTDC_SDRAM_Text (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F746NGHx STMicroelectronics
  pack: Keil.STM32F7xx_DFP.2.11.0
  cpu: IRAM(0x20000000-0x2004FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(SFPU) CPUTYPE("Cortex-M7") ELITTLE
  output: LTDC_SDRAM_Text
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F746xx
  c include: ../Inc;../Drivers/STM32F7xx_HAL_Driver/Inc;../Drivers/STM32F7xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32F7xx/Include;../Middlewares/Third_Party/FatFs/src;../Drivers/CMSIS/Include
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x50000
  group Application/MDK-ARM
    ./: startup_stm32f746xx.s
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: ff_gen_drv.c ff.c diskio.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c
  group Drivers/STM32F7xx_HAL_Driver
    ../Drivers/STM32F7xx_HAL_Driver/Src/: stm32f7xx_hal_tim.c stm32f7xx_hal_pwr_ex.c stm32f7xx_hal_i2c.c stm32f7xx_hal_flash.c stm32f7xx_ll_fmc.c stm32f7xx_hal_ltdc_ex.c stm32f7xx_hal_sd.c stm32f7xx_hal_dsi.c stm32f7xx_hal_dma_ex.c stm32f7xx_hal_pwr.c stm32f7xx_hal_flash_ex.c stm32f7xx_hal_gpio.c stm32f7xx_hal_i2c_ex.c stm32f7xx_hal_dma2d.c stm32f7xx_hal_tim_ex.c stm32f7xx_hal_rcc.c stm32f7xx_ll_sdmmc.c stm32f7xx_hal.c stm32f7xx_hal_ltdc.c stm32f7xx_hal_rng.c stm32f7xx_hal_sdram.c stm32f7xx_hal_cortex.c stm32f7xx_hal_rcc_ex.c stm32f7xx_hal_dma.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f7xx.c
  group Application/User
    ../Src/: sd_diskio.c stm32f7xx_hal_msp.c stm32f7xx_it.c fatfs.c main.c bsp_driver_sd.c LTDC.c MT48LC4M32B2.c font8.c font12.c font16.c font20.c font24.c
software components: CMSIS:CORE 4.3.0
