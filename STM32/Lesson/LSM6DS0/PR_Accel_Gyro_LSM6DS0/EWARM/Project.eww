<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\PR_Accel_Gyro_LSM6DS0.ewp</path>
  </project>
  <batchBuild />
</workspace>
